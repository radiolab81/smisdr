options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1250000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '1234'
    server: 'True'
    type: short
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: I/Q Baseband
    type: complex
  states: {}
- name: smisdr_decoder_0
  id: smisdr_decoder
  parameters:
    cmd_timeout_words: '0'
    master_clock: 50e6
    scale: '8191'
  states: {}

connections:
- [network_tcp_source_0, '0', smisdr_decoder_0, '0']
- [smisdr_decoder_0, '0', qtgui_sink_x_0, '0']
- [smisdr_decoder_0, cmd, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
