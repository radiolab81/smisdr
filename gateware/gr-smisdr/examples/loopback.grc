options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1250000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'True'
    type: short
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX
    type: complex
  states: {}
- name: smisdr_decoder_0
  id: smisdr_decoder
  parameters:
    cmd_timeout_words: '0'
    master_clock: 50e6
    scale: '8191'
  states: {}
- name: smisdr_encoder_0
  id: smisdr_encoder
  parameters:
    inject_at_start: 'True'
    master_clock: 50e6
    sample_rate: '1250000'
    scale: '8192'
    shift_hz: '1250000'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX
  states: {}

connections:
- [blocks_file_source_0, '0', smisdr_decoder_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', smisdr_encoder_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [smisdr_decoder_0, '0', qtgui_sink_x_0, '0']
- [smisdr_decoder_0, cmd, blocks_message_debug_0, print]
- [smisdr_encoder_0, '0', blocks_file_sink_0, '0']
- [smisdr_encoder_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', smisdr_decoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
