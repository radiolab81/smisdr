options:
  parameters:
    description: Steuert smisdr (rate/width) ueber TCP Port 5000
    generate_options: qt_gui
    id: smisdr_control
    output_language: python
    title: smisdr Control
  states: {}

blocks:
- name: ctrl_port
  id: variable
  parameters:
    comment: Steuerport von smi_tcp_streaming_dac
    value: '5000'
  states: {}
- name: ip_addr
  id: variable
  parameters:
    comment: IP-Adresse des smisdr Geraets
    value: '''192.168.1.129'''
  states: {}
- name: rate_scale
  id: variable
  parameters:
    comment: Skalierungsfaktor Hz -> Kommandowert, ggf. anpassen!
    value: '1000000.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Ziel-Samplerate in Hz, z.B. 1250000 -> "rate 1.25"
    value: variable_qtgui_range_0
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Samplerate Demo
    start: '250000'
    step: '100000'
    stop: '2500000'
    value: '250000'
    widget: eng_slider
  states: {}
- name: btn_width_16
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 1,1,1,1
    label: Width 16 Bit
    msgName: pressed
    type: int
    value: '16'
  states: {}
- name: btn_width_8
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 1,0,1,1
    label: Width 8 Bit
    msgName: pressed
    type: int
    value: '8'
  states: {}
- name: epy_block_rate_sender
  id: epy_block
  parameters:
    _source_code: |-
      import socket
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Sendet "rate X" per kurzlebiger TCP-Verbindung an smisdr -
          aequivalent zu 'echo -n "rate X" | nc -w1 <ip> <port>'.

          Wird auf zwei Wegen ausgeloest:
          - handle_msg(): reagiert auf (key . zahlenwert)-Paare von "Variable to Message"
          - send_now(value): oeffentliche Methode fuer den einmaligen Aufruf
            direkt nach dem Start des Flowgraphen (siehe Python-Snippet-Block)

          Jede Nachricht/jeder Aufruf oeffnet eine EIGENE Verbindung und schliesst
          sie danach wieder. Verbindungsfehler werden abgefangen, statt den
          gesamten Flowgraph zum Absturz zu bringen. Es gibt hier KEINEN Timer -
          ohne externen Trigger passiert nichts."""

          def __init__(self, ip='192.168.1.135', port=5000, scale=100000.0, timeout=1.0):
              gr.basic_block.__init__(
                  self,
                  name='rate_cmd_sender',
                  in_sig=None,
                  out_sig=None
              )
              self.ip = ip
              self.port = int(port)
              self.scale = scale
              self.timeout = timeout
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              value = pmt.to_double(pmt.cdr(msg))
              self.send_now(value)

          def send_now(self, value):
              scaled = value / self.scale
              # "{:g}" vermeidet unnoetige Nachkommastellen (1.25 statt 1.250000)
              cmd = "rate {:g}".format(scaled)
              self._send(cmd)

          def _send(self, cmd):
              try:
                  with socket.create_connection((self.ip, self.port), timeout=self.timeout) as s:
                      s.sendall(cmd.encode('ascii'))
              except OSError as e:
                  print("[smisdr] Senden fehlgeschlagen ({!r}): {}".format(cmd, e))

          def set_ip(self, ip):
              self.ip = ip

          def set_port(self, port):
              self.port = int(port)

          def set_scale(self, scale):
              self.scale = scale
    comment: Sendet "rate X" - kein interner Timer, nur externe Trigger
    ip: ip_addr
    port: ctrl_port
    scale: rate_scale
    timeout: '1.0'
  states: {}
- name: epy_block_width16_sender
  id: epy_block
  parameters:
    _source_code: |-
      import socket
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Sendet bei JEDER eingehenden Trigger-Nachricht einen fest
          konfigurierten ASCII-Befehl per kurzlebiger TCP-Verbindung an smisdr.
          Der Inhalt der eingehenden Nachricht wird bewusst NICHT ausgewertet -
          das Eintreffen selbst ist der Trigger. Das macht den Block unabhaengig
          davon, welchen genauen PMT-Typ der ausloesende Button verwendet."""

          def __init__(self, command='width 16', ip='192.168.1.135', port=5000, timeout=1.0):
              gr.basic_block.__init__(
                  self,
                  name='cmd_sender',
                  in_sig=None,
                  out_sig=None
              )
              self.command = command
              self.ip = ip
              self.port = int(port)
              self.timeout = timeout
              self.message_port_register_in(pmt.intern('trigger'))
              self.set_msg_handler(pmt.intern('trigger'), self.handle_msg)

          def handle_msg(self, msg):
              self._send(self.command)

          def _send(self, cmd):
              try:
                  with socket.create_connection((self.ip, self.port), timeout=self.timeout) as s:
                      s.sendall(cmd.encode('ascii'))
              except OSError as e:
                  print("[smisdr] Senden fehlgeschlagen ({!r}): {}".format(cmd, e))

          def set_ip(self, ip):
              self.ip = ip

          def set_port(self, port):
              self.port = int(port)

          def set_command(self, command):
              self.command = command
    command: '''width 16'''
    ip: ip_addr
    port: ctrl_port
    timeout: '1.0'
  states: {}
- name: epy_block_width8_sender
  id: epy_block
  parameters:
    _source_code: |-
      import socket
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Sendet bei JEDER eingehenden Trigger-Nachricht einen fest
          konfigurierten ASCII-Befehl per kurzlebiger TCP-Verbindung an smisdr.
          Der Inhalt der eingehenden Nachricht wird bewusst NICHT ausgewertet -
          das Eintreffen selbst ist der Trigger. Das macht den Block unabhaengig
          davon, welchen genauen PMT-Typ der ausloesende Button verwendet."""

          def __init__(self, command='width 8', ip='192.168.1.135', port=5000, timeout=1.0):
              gr.basic_block.__init__(
                  self,
                  name='cmd_sender',
                  in_sig=None,
                  out_sig=None
              )
              self.command = command
              self.ip = ip
              self.port = int(port)
              self.timeout = timeout
              self.message_port_register_in(pmt.intern('trigger'))
              self.set_msg_handler(pmt.intern('trigger'), self.handle_msg)

          def handle_msg(self, msg):
              self._send(self.command)

          def _send(self, cmd):
              try:
                  with socket.create_connection((self.ip, self.port), timeout=self.timeout) as s:
                      s.sendall(cmd.encode('ascii'))
              except OSError as e:
                  print("[smisdr] Senden fehlgeschlagen ({!r}): {}".format(cmd, e))

          def set_ip(self, ip):
              self.ip = ip

          def set_port(self, port):
              self.port = int(port)

          def set_command(self, command):
              self.command = command
    command: '''width 8'''
    ip: ip_addr
    port: ctrl_port
    timeout: '1.0'
  states: {}
- name: samp_rate_to_msg
  id: blocks_var_to_msg
  parameters:
    comment: Feuert NUR bei tatsaechlicher Aenderung von samp_rate zur Laufzeit (kein Timer)
    msgname: rate
    target: samp_rate
  states: {}
- name: send_initial_rate
  id: snippet
  parameters:
    code: self.epy_block_rate_sender.send_now(self.samp_rate)
    comment: Sendet die aktuelle Samplerate GENAU EINMAL, direkt nachdem der Flowgraph gestartet wurde. Kein Timer, keine Wiederholung.
    section: main_after_start
  states: {}

connections:
- [btn_width_16, pressed, epy_block_width16_sender, trigger]
- [btn_width_8, pressed, epy_block_width8_sender, trigger]
- [samp_rate_to_msg, msgout, epy_block_rate_sender, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
